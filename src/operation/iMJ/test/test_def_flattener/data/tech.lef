VERSION 5.8 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;

LAYER M1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.200 ;
  WIDTH 0.100 ;
  SPACING 0.100 ;
END M1

SITE CORE
  CLASS CORE ;
  SIZE 1.000 BY 1.000 ;
  SYMMETRY X Y ;
END CORE

END LIBRARY

# SPDX-License-Identifier: MulanPSL-2.0
# Copyright (c) 2026 Peng Cheng Laboratory
VERSION 5.8 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO FILL2
  CLASS CORE SPACER ;
  ORIGIN 0.000 0.000 ;
  SIZE 2.000 BY 1.000 ;
  SYMMETRY X Y ;
  SITE CORE ;
END FILL2

MACRO FILL1
  CLASS CORE SPACER ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.000 BY 1.000 ;
  SYMMETRY X Y ;
  SITE CORE ;
END FILL1

MACRO BLOCK
  CLASS CORE ;
  ORIGIN 0.000 0.000 ;
  SIZE 2.000 BY 1.000 ;
  SYMMETRY X Y ;
  SITE CORE ;
END BLOCK

END LIBRARY

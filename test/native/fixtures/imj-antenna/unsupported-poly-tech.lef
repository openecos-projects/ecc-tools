VERSION 5.8 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;

LAYER POLY
  TYPE MASTERSLICE ;
  ANTENNAMODEL OXIDE1 ;
  ANTENNAAREARATIO 2 ;
END POLY

SITE CORE
  CLASS CORE ;
  SIZE 1.000 BY 1.000 ;
  SYMMETRY X Y ;
END CORE

END LIBRARY
